# ncurses ABI version 6 is used by all major linux distros
NCURSES_ABI_VERSION = "6"