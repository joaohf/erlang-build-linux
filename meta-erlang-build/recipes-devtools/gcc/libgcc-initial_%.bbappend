require gcc-common-erlang-build.inc